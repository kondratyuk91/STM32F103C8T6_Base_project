# Keil uVision project Lesson.uvprojx, settings and files
target Lesson (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lesson1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\workspace;.\CMSIS\inc;.\Code\inc;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: startup_stm32f10x_md_vl.s
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Code
    ./Code/src/: main.c sysInit.c libUSART.c libPWM.c libADC.c libDAC.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
